# Keil uVision project AGV_F103.uvprojx, settings and files
target AGV_F103 (5050169::V5.05 update 2 (build 169)::ARMCC)
  device: STM32F103RB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x20000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AGV_F103 +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: ..\User;..\Lib\inc;..\Lib\src;..\Lib\CMSIS;..\Lib\CMSIS\startup;..\Component\inc;..\Component\src;..\..\AGV--F103;..\Algorithm\inc;..\Algorithm\src
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Lib/CMSIS/startup/: startup_stm32f10x_md.s
  group CMSIS
    ../Lib/CMSIS/: core_cm3.c core_cm3.h system_stm32f10x.c
  group Lib
    ../Lib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group User
    ../User/: main.c stm32f10x_it.c stm32f10x_conf.h common.h MySysCtrl.c
  group Component
    ../Component/src/: led.c key.c usart.c delay.c timer.c MyNVIC.c spi_hard.c task.c sd.c oled.c SDStorePara.c
  group Algorithm
    ../Algorithm/src/: MyMath.c
  group Document
    ../: record.txt
